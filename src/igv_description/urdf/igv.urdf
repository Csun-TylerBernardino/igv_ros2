Commit message: describe what changed

File: src/igv_description/urdf/igv.urdf (robot description, URDF)
Before this commit: robot igv, 3 links, 2 joints
Joints:
- joint base_to_zed: origin xyz=0.20 0.0 0.9144 rpy=0 0.506145 0 -> xyz=0.00 0.0 1.2446 rpy=0 0.5113815 0
